# Keil uVision project adt3102_hare_people_counting.uvprojx, settings and files
target adt3102_gesture_far (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: adt3102_gesture_far +hex
  AfterMake: $KARM\ARMCC\bin\fromelf.exe --bin -o .\Target_flash_eeprom.bin .\Objects\*.axf
  AfterMake: ../../bin_add_info.exe
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: CORTEX_M3,ARM_MATH_CM3,USE_FULL_ASSERT
  c misc: --c99
  c include: ..\..\..\cmsis\CMSIS\Include;..\..\..\lib\adt3102_hardwarelib\adt3102_gpio;..\..\lib\adt3102_comlib;..\..\..\lib\adt3102_hardwarelib\adt3102_spi;..\..\..\lib\adt3102_hardwarelib\adt3102_i2c;..\..\..\lib\adt3102_hardwarelib\adt3102_adc;..\..\..\lib\adt3102_hardwarelib\adt3102_dma;..\..\..\lib\adt3102_hardwarelib\adt3102_timer;..\..\..\lib\adt3102_hardwarelib\adt3102_tx;..\..\..\lib\adt3102_hardwarelib\adt3102_dsp;..\..\..\lib\adt3102_hardwarelib\adt3102_rtc;..\..\..\lib\adt3102_hardwarelib\adt3102_system;..\..\..\lib\adt3102_hardwarelib\adt3102_udp;..\..\..\..\lib\adt3102_hardwarelib\adt3102_adc;..\..\..\cmsis\CMSIS\Include;..\..\..\lib\adt3102_comlib;..\..\..\lib\adt3102_hardwarelib\adt3102_uart;..\..\..\lib\adt3102_hardwarelib\adt3102_trng;..\..\..\lib\adt3102_hardwarelib\adt3102_watchdog;..\..\..\lib\adt3102_hardwarelib\adt3102_rx;..\..\..\lib\adt3102_hardwarelib\adt3102_pmu;..\..\..\lib\adt3102_hardwarelib\adt3102_memscheduling;..\..\adt3102_mole_gesture;..\..\..\lib\adt3102_service_layer\adt3102_phase_cal;..\..\..\lib\adt3102_service_layer\adt3102_static_remove;..\..\..\lib\adt3102_hardwarelib\adt3102_timer;..\src;..\src\adt3102_inthandler;..\src;..\src\arm_fft;..\..\..\lib\adt3102_hardwarelib\adt3102_sagc;..\..\..\lib\adt3102_hardwarelib\adt3102_tinyframe;..\..\..\lib\adt3102_service_layer\adt3102_peak_single;..\..\..\lib\adt3102_hardwarelib\adt3102_utilities;..\..\..\lib\adt3102_hardwarelib\adt3102_cfar
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group startup
    ../../../lib/adt3102_comlib/: arm_bitreversal2.S
    ../../../cmsis/Device/ARM/CMSDK_CM3/Source/ARM/: startup_CMSDK_CM3.s
  group application
    ../src/: main.c proc_counting.c db_scan.c track.c
    ../src/adt3102_inthandler/: adt3102_inthandler.c
  group adt3102_lib
    ../../../lib/adt3102_hardwarelib/adt3102_adc/: adt3102_adc.c
    ../../../lib/adt3102_hardwarelib/adt3102_dma/: adt3102_dma.c
    ../../../lib/adt3102_hardwarelib/adt3102_dsp/: adt3102_dsp.c
    ../../../lib/adt3102_hardwarelib/adt3102_gpio/: adt3102_gpio.c
    ../../../lib/adt3102_hardwarelib/adt3102_i2c/: adt3102_i2c.c
    ../../../lib/adt3102_hardwarelib/adt3102_pmu/: adt3102_pmu.c
    ../../../lib/adt3102_hardwarelib/adt3102_rtc/: adt3102_rtc.c
    ../../../lib/adt3102_hardwarelib/adt3102_rx/: adt3102_rx.c
    ../../../lib/adt3102_hardwarelib/adt3102_spi/: adt3102_spi.c
    ../../../lib/adt3102_hardwarelib/adt3102_system/: adt3102_system.c
    ../../../lib/adt3102_hardwarelib/adt3102_timer/: adt3102_timer.c
    ../../../lib/adt3102_hardwarelib/adt3102_trng/: adt3102_trng.c
    ../../../lib/adt3102_hardwarelib/adt3102_tx/: adt3102_tx.c
    ../../../lib/adt3102_hardwarelib/adt3102_uart/: adt3102_uart.c
    ../../../lib/adt3102_hardwarelib/adt3102_watchdog/: adt3102_watchdog.c
    ../../../lib/adt3102_hardwarelib/adt3102_memscheduling/: adt3102_memscheduling.c
    ../../../lib/adt3102_hardwarelib/adt3102_sagc/: adt3102_sagc.c
    ../../../lib/adt3102_hardwarelib/adt3102_tinyframe/: TinyFrame.c
    ../../../lib/adt3102_hardwarelib/adt3102_utilities/: adt3102_utilities.c
  group adt3102_tool
    ../../../lib/adt3102_hardwarelib/adt3102_udp/: adt3102_udp.c socket.c w5500.c wizchip_conf.c
  group service_layer
    ../../../lib/adt3102_service_layer/adc_sample_data/: adt3102_adc_sample.c
    ../../../lib/adt3102_service_layer/adt3102_phase_cal/: adt3102_phase_cal.c
    ../../../lib/adt3102_service_layer/adt3102_static_remove/: static_remove.c
  group readme
    ./: Readme.md
