# Keil uVision project adt3102_hare_people_counting.uvprojx, settings and files
target adt3102_hare_people_counting (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: adt3102_hare_people_counting +hex (library)
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CORTEX_M3,ARM_MATH_CM3,USE_FULL_ASSERT
  c misc: --c99
  c include: ..\lib\adt3102_comlib;..\cmsis\CMSIS\Include;..\..\..\lib\adt3102_hardwarelib\adt3102_adc;..\..\..\lib\adt3102_hardwarelib\adt3102_dma;..\..\..\lib\adt3102_hardwarelib\adt3102_dsp;..\..\..\lib\adt3102_hardwarelib\adt3102_gpio;..\..\..\lib\adt3102_hardwarelib\adt3102_i2c;..\..\..\lib\adt3102_hardwarelib\adt3102_memscheduling;..\..\..\lib\adt3102_hardwarelib\adt3102_pmu;..\..\..\lib\adt3102_hardwarelib\adt3102_rtc;..\..\..\lib\adt3102_hardwarelib\adt3102_rx;..\..\..\lib\adt3102_hardwarelib\adt3102_sagc;..\..\..\lib\adt3102_hardwarelib\adt3102_spi;..\..\..\lib\adt3102_hardwarelib\adt3102_system;..\..\..\lib\adt3102_hardwarelib\adt3102_timer;..\..\..\lib\adt3102_hardwarelib\adt3102_tinyframe;..\..\..\lib\adt3102_hardwarelib\adt3102_trng;..\..\..\lib\adt3102_hardwarelib\adt3102_tx;..\..\..\lib\adt3102_hardwarelib\adt3102_uart;..\..\..\lib\adt3102_hardwarelib\adt3102_udp;..\..\..\lib\adt3102_hardwarelib\adt3102_utilities;..\..\..\lib\adt3102_hardwarelib\adt3102_watchdog;..\..\..\lib\adt3102_comlib;..\src\adt3102_inthandler;..\src\circular_queue;..\src;..\..\..\cmsis\CMSIS\Include;..\src\circular_queue;..\..\..\lib\adt3102_service_layer\adt3102_phase_cal
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group adt3102_lib
    ../../../lib/adt3102_service_layer/adt3102_phase_cal/: adt3102_phase_cal.c
    ../../../lib/adt3102_service_layer/adt3102_static_remove/: static_remove.c
    ../../../lib/adt3102_hardwarelib/adt3102_rx/: adt3102_rx.c
    ../../../lib/adt3102_hardwarelib/adt3102_tx/: adt3102_tx.c
    ../src/: ca_cfar.c db_scan.c proc_counting.c
